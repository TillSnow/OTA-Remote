# Keil uVision project IAP_F411.uvprojx, settings and files
target IAP_F411 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: IAP_F411 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Ymodem;../BSP/KEY;../BSP/KT6328;../BSP/LCD;../BSP/POWER;../SYSTEM;.\OTA;..\BSP\OWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/BSP
    ../BSP/KEY/: key.c
    ../BSP/KT6328/: KT6328.c
    ../BSP/LCD/: lcd.c lcd_init.c
    ../BSP/POWER/: power.c
    ../BSP/OWDG/: WDOG.c WDOG.h
  group Application/User/SYS
    ../SYSTEM/: delay.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Ymodem
    ../Ymodem/: common.c flash_if.c menu.c ymodem.c
  group OTA
    ./OTA/: daydream_OTA.c daydream_OTA.h
software components: CMSIS:CORE 4.3.0
